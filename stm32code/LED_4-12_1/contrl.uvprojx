# Keil uVision project contrl.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\lib\inc;.\user;.\Core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: adc.c cmd.c crc.c delay.c dog.c exti.c flash.c main.c pwm.c rcc.c rs485.c rtc.c stm32f10x_it.c system_stm32f10x.c usart.c Usart_Data_analyze.c V_Timer.c
  group lib
    ./lib/src/: misc.c stm32f10x_rcc.c stm32f10x_flash.c
  group core
    ./Core/: core_cm3.c startup_stm32f10x_hd.s
